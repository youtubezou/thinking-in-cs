# Keil uVision project arm-test.uvprojx, settings and files
target ARM-M4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: arm-test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group asm
    ./src/: asm-basic.s main.c
    ./: startup.s
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
