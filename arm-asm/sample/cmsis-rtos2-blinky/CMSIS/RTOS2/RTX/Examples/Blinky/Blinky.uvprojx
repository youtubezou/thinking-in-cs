# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 1.0.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
